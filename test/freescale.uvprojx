# Keil uVision project freescale.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: freescale
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: E:\MDK5\mak5 cxu\ARM\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
software components: Device:Startup 1.0.0
