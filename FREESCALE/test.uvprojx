# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MK60DN512xxx10 NXP
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: ARM_MATH_CM4,__FPU_PRESENT=1,__FPU_USED=1,__CC_ARM
  c include: D:\ARM\CMSIS\Include;.\Hardware
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Source Group 1
    ./: test.c
  group Hardware
    ./Hardware/: hardware.c pid.c nrf24l01.c
software components: Device:Startup 1.0.0
